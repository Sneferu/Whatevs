# Keil uVision project ECE353-S16-Project.uvprojx, settings and files
target ECE353-S16-Project (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include;../include;../drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c interrupts.c
  group Drivers
    ../drivers/: adc.c eeprom.c fonts.c gpio_port.c i2c.c lcd.c pc_buffer.c spi.c timers.c uart_irqs.c wireless.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
